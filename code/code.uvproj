# Keil uVision project code.uvproj, settings and files
target code (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: code +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\dependence;.\src
  group src
    ./src/: interrupt.c LED.c main.c tasks.c UART.c
  group dependence
    ./dependence/: 8051.h interrupt_func.h LED.h LED_func.h STARTUP.A51 UART_func.h
